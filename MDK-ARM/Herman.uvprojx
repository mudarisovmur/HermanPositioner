# Keil uVision project Herman.uvprojx, settings and files
target Herman (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Herman +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103x6
  c misc: --CPP11
  c include: ../Core/Inc;      ../Drivers/STM32F1xx_HAL_Driver/Inc;      ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FreeRTOS/Source/include;      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;      ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;      ../Drivers/CMSIS/Include;      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;      ../Core/Src/DeviceGlobal;      ../Core/Src/ObjectsDefinitions;      ../Core/Src/RtosWrappers;      ../Core/Src/Tasks;      ../Core/Src/Interrupts;      ../Core/Src/Observer;      ../Core/Src/LogicOutput;      ../Core/Src/Protocol;      ../Core/Src/Interfaces;      ../Core/Src/Kernel;      ../Core/Src/LogicInput;      ../Core/Src/Storage;      ../Core/Src/PositionControl;      ../Core/Src/Enumeration;      ../Core/Src/Calibration;      ../Core/Src/Led;      ../Core/Src/LogicControl;      ../Core/Src/LogicInputArray;      ../Core/Src/Adapter
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Adapter
    ../Core/Src/Adapter/: AdapterILogicOutputILogicInput.cpp AdapterILogicOutputILogicInput.hpp
  group Calibration
    ../Core/Src/Calibration/: Calibration.cpp Calibration.hpp
  group DeviceGlobal
    ../Core/Src/DeviceGlobal/: DeviceGlobal.cpp DeviceGlobal.hpp DeviceGlobalCalibration.cpp DeviceGlobalCalibration.hpp DeviceGlobalKernel.cpp DeviceGlobalKernel.hpp DeviceGlobaLogicOutputs.cpp DeviceGlobaLogicOutputs.hpp DeviceGlobalProtocol.cpp DeviceGlobalProtocol.hpp DeviceGlobalStorages.cpp DeviceGlobalStorages.hpp
  group Enumeration
    ../Core/Src/Enumeration/: EnumFlashRegisters.hpp EnumLed.hpp
  group Interfaces
    ../Core/Src/Interfaces/: ICalibration.hpp ILed.hpp ILogicInput.hpp ILogicOutput.hpp IObserver.hpp IPercent.hpp IPosition.hpp IPositionComplete.hpp IProcess.hpp IStorage.hpp
  group Interrupts
    ../Core/Src/Interrupts/: INT_timer.cpp INT_uart.cpp
  group Kernel
    ../Core/Src/Kernel/: Kernel.cpp Kernel.hpp
  group Led
    ../Core/Src/Led/: Led.cpp Led.hpp
  group LogicControl
    ../Core/Src/LogicControl/: LogicControl.cpp LogicControl.hpp
  group LogicInput
    ../Core/Src/LogicInput/: LogicInput.cpp LogicInput.hpp
  group LogicInputArray
    ../Core/Src/LogicInputArray/: LogicInputArray.cpp LogicInputArray.hpp
  group LogicOutput
    ../Core/Src/LogicOutput/: LogicOutput.cpp LogicOutput.hpp
  group ObjectsDefinitions
    ../Core/Src/ObjectsDefinitions/: ObjectsDefinitions.cpp ObjectsDefinitions.hpp
  group Observer
    ../Core/Src/Observer/: ObserverAggregator.cpp ObserverAggregator.hpp
  group PositionControl
    ../Core/Src/PositionControl/: PositionControl.cpp PositionControl.hpp
  group Protocol
    ../Core/Src/Protocol/: Protocol.cpp Protocol.hpp
  group RtosWrappers
    ../Core/Src/RtosWrappers/: SemaphoreWrapper.cpp SemaphoreWrapper.hpp
  group Storage
    ../Core/Src/Storage/: StorageFlash.cpp StorageFlash.hpp StorageFlashDefault.hpp
  group Tasks
    ../Core/Src/Tasks/: Task200mks.cpp
software components: CMSIS:CORE 4.3.0
